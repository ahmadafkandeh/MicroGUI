# Keil uVision project testproject.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: testproject
  c flags: Optim=1 oTime=1 wLevel=2
  c include: .\Sources;..\GUI;..\GUI\Manager;..\GUI\GUILib;..\GUI\GUILib\Templates;..\GUI\Driver;..\GUI\Driver\Drivers\LPC17xx\DisplayDriver;..\GUI\Driver\Drivers\LPC17xx\MouseDriver;..\GUI\Driver\Drivers\LPC17xx\MouseDriver\Touch3inch;..\GUI\OS\FreeRTOS\include;..\GUI\OS\FreeRTOS\portable\RVDS\ARM_CM3;..\GUI\OS\FreeRTOS;..\GUI\OS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group proj
    ./Sources/Project Files/: main.cpp
  group Startup Files
    ./Sources/Project Files/startup Files/: startup_LPC17xx.s system_LPC17xx.c
  group Drivers
    ../GUI/Driver/: DisplayDriver.cpp MouseDriver.cpp
  group Manager
    ../GUI/Manager/: CWinMan.cpp HeapManager.cpp
  group Display Files
    ../GUI/Driver/Drivers/LPC17xx/DisplayDriver/TFT3inc/: lcd.cpp
  group Mouse Drivers
    ../GUI/Driver/Drivers/LPC17xx/MouseDriver/Touch3inch/: i2c.c LCD_touch.c
  group GUI Lib
    ../GUI/GUILib/: CButton.cpp CCheckBox.cpp CForm.cpp CIPMasked.cpp CLabel.cpp CObject.cpp CWnd.cpp CTextBox.Cpp CScrollBar.cpp CMemo.cpp CListBox.cpp CContainer.cpp
  group OS_FREERTOS
    ../GUI/OS/FreeRTOS/: list.c queue.c tasks.c
    ../GUI/OS/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../GUI/OS/FreeRTOS/MemMang/: heap_4.cpp
  group OS Files
    ../GUI/OS/FreeRTOS/: OSFunc_FreeRTOS.c
